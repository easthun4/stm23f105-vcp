# Keil uVision project rt-wifi.uvproj, settings and files
target Target 1 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: IRAM(0x20000000-0x2000FFFF) IROM(0x8000000-0x803FFFF) CLOCK(25000000) CPUTYPE("Cortex-M3")
  output: rt-wifi +hex
  c flags: Optim=1
  c misc: --feedback=wifi.feedback --gnu
  c include: .\include;.\bsp\stm3210\project_full;.\bsp\stm3210\Libraries\CMSIS\CM3\CoreSupport;.\bsp\stm3210\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\bsp\stm3210\Libraries\STM32F10x_StdPeriph_Driver\inc;.\libcpu\arm\stm32;.\net\lwip\src\include;.\net\lwip\src;.\net\lwip\src\arch\include;.\net\lwip\src\include\ipv4;.\net\driver;.\net\driver\88w8686;.\usb\stm32_lib\Libraries\STM32_USB_HOST_Driver\inc;.\usb\stm32_lib\Libraries\STM32_USB_HOST_Library\Core\inc;C:\UDiskPrgTest\Src_UsbHost;.\usb\linux;.\src;.\exg\include;.\adb\include;.\usb\bsp;.\usb\stm32_lib\Libraries\STM32_USB-FS-Device_Driver\inc;.\usb\hid_device\include
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --remove --vfemode=on --feedback=wifi.feedback
  group CMSIS
    ./bsp/stm3210/Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: stm32f10x.h system_stm32f10x.h system_stm32f10x.c
    ./bsp/stm3210/Libraries/CMSIS/CM3/CoreSupport/: core_cm3.h core_cm3.c
  group BSP
    ./bsp/stm3210/project_full/: startup.c board.h board.c rtconfig.h usart.h usart.c stm32f10x_it.h stm32f10x_it.c application.c rtc.h rtc.c led.c usbd_usr.c usb_bsp.c usbd_cdc_vcp.c usbd_desc.c
  group StdPeriph_Driver
    ./bsp/stm3210/Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_bkp.c stm32f10x_rtc.c stm32f10x_pwr.c stm32f10x_dma.c stm32f10x_exti.c stm32f10x_spi.c stm32f10x_tim.c stm32f10x_adc.c
    ./bsp/stm3210/Libraries/STM32F10x_StdPeriph_Driver/inc/: misc.h stm32f10x_rcc.h stm32f10x_gpio.h stm32f10x_usart.h stm32f10x_bkp.h stm32f10x_rtc.h stm32f10x_pwr.h stm32f10x_dma.h
  group libcpu
    ./libcpu/arm/stm32/: start_rvds.S context_rvds.S cpu.c fault.c fault_rvds.S serial.c serial.h stack.c interrupt.c
  group src
    ./src/: scheduler.c thread.c timer.c clock.c device.c idle.c ipc.c irq.c kservice.c kservice.h mem.c mempool.c object.c
  group include
    ./include/: rtthread.h rtdef.h rthw.h
  group exg
    ./exg/src/: exg_data_buffer.c SoftwareSPI.c Sensor701.c
  group usb_device
    ./usb/Device/Core/src/: usbd_req.c usbd_core.c usbd_ioreq.c
    ./usb/Device/Class/cdc/src/: usbd_cdc_core.c
    ./usb/OTG/src/: usb_dcd.c usb_dcd_int.c usb_core.c
target ad7947 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: as above
  output: rt-wifi +hex
  c flags: Optim=1
  c misc: --feedback=wifi.feedback --gnu
  c include: .\include;.\bsp\stm3210\project_full;.\bsp\stm3210\Libraries\CMSIS\CM3\CoreSupport;.\bsp\stm3210\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\bsp\stm3210\Libraries\STM32F10x_StdPeriph_Driver\inc;.\libcpu\arm\stm32;.\net\lwip\src;.\net\lwip\src\include;.\net\lwip\src\arch\include;.\net\lwip\src\include\ipv4;.\net\driver;.\net\driver\88w8686;C:\UDiskPrgTest\Src_UsbHost;.\src;.\exg\include;.\adb\include;.\usb\Device\Core\inc\;.\usb\OTG\inc\;.\usb\Device\Class\cdc\inc\
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --remove --vfemode=on --feedback=wifi.feedback
target adinternal (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: as above
  output: rt-wifi +hex
  c flags: Optim=1
  c misc: --feedback=wifi.feedback --gnu
  c include: .\include;.\bsp\stm3210\project_full;.\bsp\stm3210\Libraries\CMSIS\CM3\CoreSupport;.\bsp\stm3210\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;.\bsp\stm3210\Libraries\STM32F10x_StdPeriph_Driver\inc;.\libcpu\arm\stm32;.\net\lwip\src\include;.\net\lwip\src;.\net\lwip\src\arch\include;.\net\lwip\src\include\ipv4;.\net\driver;.\net\driver\88w8686;.\usb\stm32_lib\Libraries\STM32_USB_HOST_Driver\inc;.\usb\stm32_lib\Libraries\STM32_USB_HOST_Library\Core\inc;C:\UDiskPrgTest\Src_UsbHost;.\usb\linux;.\src;.\exg\include;.\adb\include;.\usb\bsp;.\usb\stm32_lib\Libraries\STM32_USB-FS-Device_Driver\inc;.\usb\hid_device\include;.\usb\Device\Class\cdc\inc;.\usb\Device\Core\inc;.\usb\OTG\inc
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --remove --vfemode=on --feedback=wifi.feedback
target Sensor701 (ARM-ADS)
  device: STM32F105RC STMicroelectronics
  cpu: as above
  output: rt-wifi +hex
  c flags: Optim=1
  c misc: --feedback=wifi.feedback --gnu
  c include: as above
  memory RVCT4: ROM 0x8000000 size 0xc000
  memory RVCT9: RAM 0x20000000 size 0x10000
  link misc: --remove --vfemode=on --feedback=wifi.feedback
